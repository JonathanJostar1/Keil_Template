# Keil uVision project N32G45x_Template.uvprojx, settings and files
target N32G45x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G455VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G45x +hex
  AfterMake: fromelf.exe --bin --output=.\Output\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\APP\Inc;..\Firmware\CMSIS\core;..\Firmware\CMSIS\device;..\Firmware\n32g45x_std_periph_driver\inc;..\BSP\Inc;..\3rdParty\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group USER
    ../APP/Src/: main.c n32g45x_it.c
  group BSP
    ../BSP/Src/: delay.c log.c print_remap.c
  group CMSIS
    ../Firmware/CMSIS/device/: system_n32g45x.c
    ../Firmware/CMSIS/device/startup/: startup_n32g45x.s
  group FWLB
    ../Firmware/n32g45x_std_periph_driver/src/: n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c misc.c
  group DOC
    ../: README.md
